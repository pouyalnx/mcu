# Keil uVision project prj.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: prj
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: "__packed=__attribute__((__packed__))"
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c a4988.c USBD_User_CDC_ACM_0.c servo.c gcode.c gcode.h
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS:Keil RTX 4.82.0, USB:CORE 6.15.0, USB:Device 6.15.0, USB:Device:CDC 6.15.0, CMSIS Driver:USB Device 2.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0
