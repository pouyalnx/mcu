# Keil uVision project prj.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: prj
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group main
    ./: main.c app.c USBD_User_CDC_ACM_0.c tlcode.c stepper.c servo.c
  group gcode
    ./: gcode.c gcmd.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS:Keil RTX 4.82.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, USB:CORE 6.15.0, USB:Device 6.15.0, USB:Device:CDC 6.15.0, CMSIS Driver:USB Device 2.14.0, Device:PIN 1.0.0, Device:Startup 1.0.0
